# Keil uVision project carlab_302_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: carlab_302_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h Pin_2_aliases.h Pin_2.c Pin_2.h LCD.c LCD.h LCD_PM.c LCD_LCDPort_aliases.h LCD_LCDPort.c LCD_LCDPort.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h Pin_1_aliases.h Pin_1.c Pin_1.h inter_HE.c inter_HE.h UART.c UART.h UART_PM.c UART_INT.c PWM_Servo.c PWM_Servo.h PWM_Servo_PM.c Clock_Servo.c Clock_Servo.h Pin_3_aliases.h Pin_3.c Pin_3.h Pin_4_aliases.h Pin_4.c Pin_4.h Pin_5_aliases.h Pin_5.c Pin_5.h Pin_6_aliases.h Pin_6.c Pin_6.h inter_horizontalSync.c inter_horizontalSync.h inter_verticalSync.c inter_verticalSync.h inter_comparator.c inter_comparator.h Timer_HE.c Timer_HE.h Timer_HE_PM.c Timer_Nav.c Timer_Nav.h Timer_Nav_PM.c Clock_Nav.c Clock_Nav.h PWM_Motor.c PWM_Motor.h PWM_Motor_PM.c Clock_Motor.c Clock_Motor.h Pin_7_aliases.h Pin_7.c Pin_7.h Clock_Infrared.c Clock_Infrared.h Pin_8_aliases.h Pin_8.c Pin_8.h inter_infrared_rising_1.c inter_infrared_rising_1.h Timer_Infrared_1.c Timer_Infrared_1.h Timer_Infrared_1_PM.c inter_infrared_falling_1.c inter_infrared_falling_1.h Pin_9_aliases.h Pin_9.c Pin_9.h inter_infrared_rising_2.c inter_infrared_rising_2.h Timer_Infrared_2.c Timer_Infrared_2.h Timer_Infrared_2_PM.c inter_infrared_falling_2.c inter_infrared_falling_2.h Pin_10_aliases.h Pin_10.c Pin_10.h inter_infrared_rising_3.c inter_infrared_rising_3.h Timer_Infrared_3.c Timer_Infrared_3.h Timer_Infrared_3_PM.c inter_infrared_falling_3.c inter_infrared_falling_3.h inter_infrared_rising_0.c inter_infrared_rising_0.h Timer_Infrared_0.c Timer_Infrared_0.h Timer_Infrared_0_PM.c inter_infrared_falling_0.c inter_infrared_falling_0.h Control_Reg.c Control_Reg.h Pin_11_aliases.h Pin_11.c Pin_11.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: carlab_302_PSoC5lib (library)
